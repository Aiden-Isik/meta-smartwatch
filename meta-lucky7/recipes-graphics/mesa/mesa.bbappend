PACKAGECONFIG:append:lucky7 = " kmsro panfrost gallium-llvm"
