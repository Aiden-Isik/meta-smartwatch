CFLAGS:append:lucky7 = " -DLPM_DORY"
