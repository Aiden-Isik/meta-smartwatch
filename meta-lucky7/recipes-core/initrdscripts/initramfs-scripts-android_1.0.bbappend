FILESEXTRAPATHS:prepend:kernel-lucky7 := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:kernel-lucky7 = "kernel-lucky7"
