# This watch has a sufficiently new kernel that it's supported
PACKAGECONFIG:append:lucky7 = " pstore "
