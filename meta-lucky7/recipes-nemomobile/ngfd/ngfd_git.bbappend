RDEPENDS:${PN}:append:lucky7 = " ngfd-plugin-droid-vibrator "
