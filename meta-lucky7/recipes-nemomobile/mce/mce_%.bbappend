FILESEXTRAPATHS:prepend:lucky7 := "${THISDIR}/${PN}:"

SRC_URI:append:lucky7 = " file://0001-Display-Hack-to-put-screen-to-sleep-on-Rinato.patch "

