RDEPENDS:${PN}:append:lucky7 = " qt5-qpa-hwcomposer-plugin "
